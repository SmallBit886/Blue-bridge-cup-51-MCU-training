# Keil uVision project 21521840727.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 21521840727 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\模拟测试
  group Source Group 1
    ./: main.c Timer.c Key.c SMG.c IIC.c LED.c E2PROM.c DS1302.c sys.c Delay.c
